ORG 0000H
MOV TMOD,#20H
MOV TH1,#-3
MOV SCON,#50H
SETB TR1
MOV P2,#00H
MAIN:
JB RI,RECIEVE
SJMP SEND
RECIEVE:
CLR A
NEXT: JNB RI,NEXT
MOV A,SBUF
MOV P2,A
CLR RI
SJMP MAIN
SEND:
MOV DPTR,#0200H
MOV R0,#0FH
LOOP: CLR A
MOVC A,@A+DPTR
MOV SBUF,A
AGAIN: JNB TI,AGAIN
CLR TI
INC DPTR
DJNZ R0,LOOP
SJMP MAIN

ORG 0200H
DB "VIT UNIVERSITY "
END