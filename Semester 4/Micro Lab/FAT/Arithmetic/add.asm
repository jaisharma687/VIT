ORG 0000H
MOV R0,#05H
MOV R1,#00H
MOV R2,#00H
CLR PSW.7
MOV DPTR,#0200H
MAIN: CLR A
MOVC A,@A+DPTR
ADD A,R1
MOV R1,A
JNC NEXT
INC R2
CLR PSW.7
NEXT: INC DPTR
DJNZ R0,MAIN
CLR A
MOV R0,#40H
MOV A,R2
MOV @R0,A
INC R0
MOV A,R1
MOV @R0,A
HERE: SJMP HERE
ORG 0200H
DB 92H,23H,66H,87H,0F5H
END