ORG 0000H
MOV TMOD,#61H
SETB P1.2
MOV TH1,#0
MOV TL1,#0
SETB TR1
MOV R0,#10
AGAIN: MOV A,TL1
MOV P2,A
DJNZ R0,AGAIN
CLR TR1
CLR TF1
MAIN:
SETB P1.2
ACALL DELAY
CLR P1.2
ACALL DELAY
SJMP MAIN
DELAY:
MOV TH0,#0FFH
MOV TL0,#0CCH
SETB TR0
BACK: JNB TF0,BACK
CLR TF0
CLR TR0
RET
END