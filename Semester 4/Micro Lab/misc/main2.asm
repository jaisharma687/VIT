ORG 0000H
MOV TMOD,#01H
MAIN:
CPL P1.4
JB P1.0, LSB_One
LSB_Zero:
JB P1.7, One_Zero
Zero_Zero:
MOV TL0,#9AH
MOV TH0,#03H
ACALL DELAY
SJMP MAIN
One_Zero:
MOV TL0,#67H
MOV TH0,#02H
ACALL DELAY
SJMP MAIN
LSB_One:
JB P1.7, One_One
Zero_One:
MOV TL0,#20H
MOV TH0,#01H
ACALL DELAY
SJMP MAIN
One_One:
MOV TL0,#0E7H
MOV TH0,#00H
ACALL DELAY
SJMP MAIN

DELAY: SETB TR0
AGAIN: JNB TF0,AGAIN
CLR TR0
CLR TF0
RET
END