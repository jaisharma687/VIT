#include <stdio.h>

int main() {
    int a[4][8] = {
        {2, 7, 9, 3, 4, 8, 4, 3},
        {0, 2, 3, 1, 3, 4, 0, 0},
        {0, 2, 1, 2, 2, 1, 0, 0},
        {4, 8, 5, 6, 4, 5, 7, 2}
    };
    
    int f1[8] = {0}; 
    f1[1] = a[0][0] + a[0][1];
    
    int f2[8] = {0}; 
    f2[1] = a[3][0] + a[3][1];
    
    int f = 0;
    
    for (int j = 2; j < 8; j++) {
        if (f1[j - 1] + a[0][j] <= f2[j - 1] + a[2][j - 1] + a[0][j]) {
            f1[j] = f1[j - 1] + a[0][j];
        } 
        else {
            f1[j] = f2[j - 1] + a[2][j - 1] + a[0][j];
        }
        
        if (f2[j - 1] + a[3][j] <= f1[j - 1] + a[1][j - 1] + a[3][j]) {
            f2[j] = f2[j - 1] + a[3][j];
        } 
        else {
            f2[j] = f1[j - 1] + a[1][j - 1] + a[3][j];
        }
    }
    if (f1[7] + a[0][7] <= f2[7] + a[3][7]) {
        f = f1[7] + a[0][7];
    } 
    else {
        f = f2[7] + a[3][7];
    }
    printf("%d", f);
    return 0;
}
